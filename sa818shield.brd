# Repository urukakanko/arduino_sa818shield2

File README.md:

Arduino　アマチュア無線シールド２（バージョンアップ）です
3.3Vインターフェース対応と、マイク入力部に外部からの入力を追加しました。
ESP32基板（AitendoのIoTExpress MK2をターゲット）だと、たとえばPTTを押したときにコールサインを自動送信　なんて事も。

## EAGLE design sa818shield.brd

Parts:
AUDIO: TPPAD1-13; P1-13
C1, C11: 0.1u; C025-024X044
C2, C6: 0.01u; C025-024X044
C3: 470u; E5-10,5
C4: 0.047u; C025-024X044
C5: 220u; CPOL-RADIAL-10UF-25V
C7, C8, C9, C10: C-USC0805K; C0805K
CN1: MRUSB-2B-D14NI-S306
GND: TPPAD1-13; P1-13
IC1: LM386N-1; DIL08
MIC: TPPAD1-13; P1-13
Q1: 2SC1815-SILK; TO92-ECB
R1, R4: 2.2k; 0204/5
R2, R3, R7: 10k; 0204/5
R5, R10: 3.3k; 0204/5
R6: TRIM_EU-S63S; S63S
R8: 100k; 0204/5
R9: 1k; 0204/5
S1, S2, S3, S4: SWITCH-MOMENTARY-2SIDE_EZ; TACTILE-PTH-SIDEEZ
S5: SK12D07
SPK+: TPPAD1-13; P1-13
SPK-: TPPAD1-13; P1-13
TP1, TP2, TP3, TP4, TP5, TP6: TPTP20SQ; TP20SQ
U1: SA818
U2: ARDUINOR3-DIMENSION; ARDUINOR3
U3: C9767
U$1: OLED_0.96_I2C
X1: SMA-142-0711-821/826; J502-ND-142-0711-821/826

Connections:
3V: U2.3V
GND: C2.2, C3.-, C6.2, C7.2, C8.2, C9.2, C10.2, CN1.GND, CN1.SHEELD1, CN1.SHEELD2, GND.TP, IC1.2 (-IN), IC1.4 (GND), Q1.E, R5.1, R6.E, R7.1, R9.1, R10.1, S1.1, S2.2, S3.2, S4.2, SPK-.TP, U1.9 (GND), U1.10 (GND), U1.FG1 (FG), U1.FG2 (FG), U2.GND, U2.GND1, U2.GND2, U3.-, U$1.GND, X1.G@1 (2), X1.G@2 (2), X1.G@3 (2), X1.G@4 (2)
unnamed: C9.1, TP4.TP, TP5.TP
unnamed: U2.SCL, U$1.SCL
unnamed: U2.SDA, U$1.SDA
unnamed: CN1.VBUS, S5.2
unnamed: R1.1, R10.2, U2.D9
unnamed: C1.1, R2.1, U3.+
unnamed: S4.1, U2.D6
unnamed: U1.16 (RXD), U2.D2
unnamed: R4.1, U1.17 (TXD)
unnamed: R3.2, U2.D4
unnamed: U1.6 (PD), U2.D5
unnamed: C1.2, C11.2, MIC.TP, U1.18 (MIC_IN)
unnamed: S3.1, U2.D7
unnamed: S2.1, U2.D8
unnamed: IC1.3 (+IN), R6.S
unnamed: C5.2 (-), SPK+.TP
unnamed: AUDIO.TP, R6.A, U1.3 (AF_OUT)
unnamed: C4.1, C5.1 (+), IC1.5 (OUT)
unnamed: C4.2, R7.2
unnamed: R8.2, U2.D10
unnamed: C7.1, TP1.TP, U1.12 (ANT)
unnamed: S1.2, U1.5 (PTT)
unnamed: C8.1, TP2.TP, TP3.TP
unnamed: C10.1, TP6.TP, X1.1
unnamed: Q1.B, R3.1
unnamed: Q1.C, U1.7 (H/L)
unnamed: R4.2, R5.2, U2.D3
unnamed: C11.1, R8.1, R9.2
VCC: C2.1, C3.+, C6.1, IC1.6 (VS), R1.2, R2.2, S5.3 (S), U1.8 (VBAT), U2.5V, U$1.VCC
VIN: U2.VIN

Notes on the sheet:
π型フィルタを構成 コイルはTPパットに実装する

Board: 2 copper layers, 68.6 x 53.3 mm, 45 parts (12 on the bottom side), 30 nets.

Notices in the files:
parts and their libraries:
SparkFun-Electromechanical: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
